# Keil uVision project PFC.uvprojx, settings and files
target PFC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F765VGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF)   CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: PFC +hex
  BeforeMake: .\version.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F765xx
  c misc: --unaligned_access --diag_error=warning
  c include: ../drivers;../drivers/STM32F7xx_HAL_Driver/Inc;../drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../drivers/CMSIS/Device/ST/STM32F7xx/Include;../drivers/CMSIS/Include;../application;../hardware;../middleware/eeprom;../middleware/serial_interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --unaligned_access
  group system
    ./: startup_stm32f765xx.s
  group hardware
    ../hardware/: stm32f7xx_hal_conf.h stm32f7xx_it.c stm32f7xx_it.h
  group drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c
  group drivers/CMSIS
    ../drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
    ../drivers/CMSIS/Device/ST/STM32F7xx/Include/: system_stm32f7xx.h
    ../drivers/CMSIS/Include/: core_cm7.h
  group middleware/serial_interface
    ../middleware/serial_interface/: crc.c crc.h protocol.c protocol.h
  group application
    ../application/: main.c defines.h adc_logic.c adc_logic.h pfc_logic.c pfc_logic.h command_processor.c command_processor.h events.c events.h events_process.c events_process.h settings.c settings.h
  group middleware/eeprom
    ../middleware/eeprom/: eeprom_emulation.c eeprom_emulation.h
  group drivers
    ../drivers/: bver.h fw_ver.h
  group hardware/BSP
    ../hardware/BSP/: adc.c adc.h timer.c timer.h iwdg.c iwdg.h uart.c uart.h debug.c debug.h dma.c dma.h gpio.c gpio.h system.c system.h bsp.c bsp.h
    ../hardware/board/: board_stm32f7.h
software components: CMSIS:CORE 4.3.0
